# Keil uVision project sensor_beacon.uvprojx, settings and files
target sensor_beacon (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: tp_beacon_002 +hex
  c flags: Optim=4
  c define: SYS_CFG_USE_TWI0, SYS_CFG_SERIAL_0_IRQ_PRIORITY= 3, PCA20014, TEMPERATURE_AND_PRESSURE_BEACON
  c misc: --c99
  c include: ..\..\..\inc;..\..\..\external\framework\cunit;..\..\..\external\comp_generic\hal\inc;..\..\..\..\..\..\components\ble\ble_services\experimental_ble_pdlp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\scatter.sct
  group app
    ../../../src/: sensor_beacon.c
    ../../../../../../components/ble/ble_services/experimental_ble_pdlp/: ble_pdlp_common.c
  group libs
    ../../../src/: drv_lps25h.c hal_clock.c hal_radio.c hal_timer.c
    ../../../external/comp_generic/hal/src/: hal_serial.c hal_twi.c
software components: CMSIS:CORE 3.20.0, Device:Startup 8.0.0
