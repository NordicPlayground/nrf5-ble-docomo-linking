# Keil uVision project linking_beacon.uvprojx, settings and files
target sensor_beacon (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: tp_beacon_002 +hex
  c flags: Optim=4
  c misc: --c99
  c include: ..\..\..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\scatter.sct
  group app
    ../../../src/: sensor_beacon.c
  group libs
    ../../../src/: hal_clock.c hal_radio.c hal_timer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.7.1
