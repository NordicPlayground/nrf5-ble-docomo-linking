# Keil uVision project linking_beacon.uvprojx, settings and files
target sensor_beacon (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: tp_beacon_002 +hex
  c flags: Optim=4
  c define: FPU_INTERRUPT_MODE,NRF52
  c misc: --c99
  c include: ..\..\..\inc;..\..\..\..\..\..\..\components\ble\ble_services\experimental_ble_pdlp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\scatter.sct
  group app
    ../../../src/: sensor_beacon.c
    ../../../../../../../components/ble/ble_services/experimental_ble_pdlp/: ble_pdlp_common.c
  group libs
    ../../../src/: hal_clock.c hal_radio.c hal_timer.c
software components: CMSIS:CORE 3.20.0, Device:Startup 8.0.0
